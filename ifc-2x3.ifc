Properties of the parts of a building model (IFC2X3)

# File
Description: Taupunktsensor für Kühldecken/Matte, 10 m Kabel, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: G8000299, Taupunktsensor für Kühldecken/Matte, 10 m Kabel
In: Raum
Description: Dieser Taupunktfühler wurde in Verbindung mit einem alre-Taupunktwächter (z. B. WFRRN) oder -Kühldeckenregler (z. B. KTRRB, KTRRU, KTRRUu, KTRVB, KTFRx) speziell zur Erfassung und Meldung des Taupunktes entwickelt. Er verhindert somit bei korrekter Montage abtropfendes Kondenswasser von den gekühlten Teilen des Kühlkreislaufs. Verwendung: Trockenbaukühldecke (Gipskartonplatte) mit aufgelegter Kapillarrohrmatte, Metallkühldecke mit integriertem Kapillarrohrsystem. Die Montage/Befestigung erfolgt mittels Clips am Kühldecken-Kapillarrohr. Fühlerleitung verlängerbar bis 50 m mit 2 x 0,5 mm².; Classification: EC004240 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: G8000299; ModelLabel: TPS 1; GlobalTradeItemNumber: 4050528034663; ProductURL: https://alre.de/produkt_G8000299
Pset_Specification - NominalLength: 0.07 m; NominalWidth: 0.036 m; NominalDepth: 0.0215 m; NetWeight: 0.075
Pset_ALRE_ETIM_Properties - Kabellänge: 10; Art der Spannungsversorgung: ohne; Explosionsgeschützt: no; Schutzart (IP): IP30; Mit Befestigungsmaterial: yes; Gehäusehöhe: 21.5; Gehäusebreite: 70; Gehäusetiefe: 36; Festes Kabel am Sensor: yes; ETIM-Klasse: EC004240; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-G8000299.pdf
